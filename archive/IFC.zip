Properties of the parts of a building model (IFC2X3)

# File
Description: model build from MIDAS
Time: 2026-06-10T16:19:52

# IfcProject, D_40_3L_OF_P_Superstructure
LongName: D_40_3L_OF_P_Superstructure

# IfcBuildingStorey, floor#1
In: The building
Elevation: -2.43 m
