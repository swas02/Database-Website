Properties of the parts of a building model (IFC2X3)

# File
Description: model build from MIDAS
Time: 2026-06-10T15:16:01

# IfcProject, D_30_2L_NF_P_Superstructure
LongName: D_30_2L_NF_P_Superstructure

# IfcBuildingStorey, floor#1
In: The building
Elevation: -2.035 m
