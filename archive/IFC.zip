Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: ff9ff849-6920-415f-8279-ddbd900f3f95, VersionGUID: c334fe18-ae37-4422-b504-30e0f2762f7b, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates]
File name: D_30_2L_OF_S_Sub.ifc
Time: 2026-06-24T15:45:25+05:30
Written by: ODA SDAI 25.12
Made in: Autodesk - Revit 27.0.20.10 (ENU) - 27.0.20.10

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, The site:1246240
RefLatitude: 42, 21, 31, 401672; RefLongitude: -71, -3, -24, -345703; RefElevation: 0 ft; Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcBuilding, Building Name
LongName: Building Name
Pset_BuildingCommon - NumberOfStoreys: 2

# IfcBuildingStorey (2)
In: Building Name
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (ft)
L1 | L1 | 0
L2 | L2 | 12

# IfcBeam: Direct Shape:Beam#52, Beam#52
In: L1
Type - PredefinedType: BEAM; Material: <Unnamed>
Type - Pset_BeamCommon - Slope: 0 deg; LoadBearing: yes
Pset_BeamCommon - IsExternal: no; Reference: Beam#52
Pset_QuantityTakeOff - Reference: Beam#52; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcBeam: Direct Shape:Beam#53, Beam#53
In: L1
Type - PredefinedType: BEAM; Material: <Unnamed>
Type - Pset_BeamCommon - Slope: 0 deg; LoadBearing: yes
Pset_BeamCommon - IsExternal: no; Reference: Beam#53
Pset_QuantityTakeOff - Reference: Beam#53; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcBeam: Direct Shape:Beam#54, Beam#54
In: L1
Type - PredefinedType: BEAM; Material: <Unnamed>
Type - Pset_BeamCommon - Slope: 0 deg; LoadBearing: yes
Pset_BeamCommon - IsExternal: no; Reference: Beam#54
Pset_QuantityTakeOff - Reference: Beam#54; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcBeam: Direct Shape:Beam#55, Beam#55
In: L1
Type - PredefinedType: BEAM; Material: <Unnamed>
Type - Pset_BeamCommon - Slope: 0 deg; LoadBearing: yes
Pset_BeamCommon - IsExternal: no; Reference: Beam#55
Pset_QuantityTakeOff - Reference: Beam#55; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcBeam: Direct Shape:Beam#56, Beam#56
In: L1
Type - PredefinedType: BEAM; Material: <Unnamed>
Type - Pset_BeamCommon - Slope: 0 deg; LoadBearing: yes
Pset_BeamCommon - IsExternal: no; Reference: Beam#56
Pset_QuantityTakeOff - Reference: Beam#56; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcBeam: Direct Shape:Beam#57, Beam#57
In: L1
Type - PredefinedType: BEAM; Material: <Unnamed>
Type - Pset_BeamCommon - Slope: 0 deg; LoadBearing: yes
Pset_BeamCommon - IsExternal: no; Reference: Beam#57
Pset_QuantityTakeOff - Reference: Beam#57; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcBeam: Direct Shape:Beam#58, Beam#58
In: L1
Type - PredefinedType: BEAM; Material: <Unnamed>
Type - Pset_BeamCommon - Slope: 0 deg; LoadBearing: yes
Pset_BeamCommon - IsExternal: no; Reference: Beam#58
Pset_QuantityTakeOff - Reference: Beam#58; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcBeam: Direct Shape:Beam#59, Beam#59
In: L1
Type - PredefinedType: BEAM; Material: <Unnamed>
Type - Pset_BeamCommon - Slope: 0 deg; LoadBearing: yes
Pset_BeamCommon - IsExternal: no; Reference: Beam#59
Pset_QuantityTakeOff - Reference: Beam#59; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcBuildingElementProxy: Structural Framing 1:Structural Framing 1, Structural Framing 1:Structural Framing 1:1245899
In: L1
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Structural Framing 1; sets with these values: 2
Group: Model Group:Group 1:1246292

# IfcColumn: Direct Shape:Column#11, Column#11
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#11
Pset_QuantityTakeOff - Reference: Column#11; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#12, Column#12
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - Reference: Column#12; IsExternal: no
Pset_QuantityTakeOff - Reference: Column#12; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#13, Column#13
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#13
Pset_QuantityTakeOff - Reference: Column#13; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#14, Column#14
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#14
Pset_QuantityTakeOff - Reference: Column#14; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#15, Column#15
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#15
Pset_QuantityTakeOff - Reference: Column#15; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#16, Column#16
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#16
Pset_QuantityTakeOff - Reference: Column#16; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#17, Column#17
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#17
Pset_QuantityTakeOff - Reference: Column#17; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#18, Column#18
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#18
Pset_QuantityTakeOff - Reference: Column#18; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#19, Column#19
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#19
Pset_QuantityTakeOff - Reference: Column#19; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#20, Column#20
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#20
Pset_QuantityTakeOff - Reference: Column#20; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#21, Column#21
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#21
Pset_QuantityTakeOff - Reference: Column#21; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#22, Column#22
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#22
Pset_QuantityTakeOff - Reference: Column#22; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#23, Column#23
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#23
Pset_QuantityTakeOff - Reference: Column#23; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#24, Column#24
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#24
Pset_QuantityTakeOff - Reference: Column#24; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#25, Column#25
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#25
Pset_QuantityTakeOff - Reference: Column#25; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#26, Column#26
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#26
Pset_QuantityTakeOff - Reference: Column#26; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#27, Column#27
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#27
Pset_QuantityTakeOff - Reference: Column#27; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#28, Column#28
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#28
Pset_QuantityTakeOff - Reference: Column#28; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#29, Column#29
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#29
Pset_QuantityTakeOff - Reference: Column#29; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#30, Column#30
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#30
Pset_QuantityTakeOff - Reference: Column#30; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#31, Column#31
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#31
Pset_QuantityTakeOff - Reference: Column#31; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#32, Column#32
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#32
Pset_QuantityTakeOff - Reference: Column#32; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#33, Column#33
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#33
Pset_QuantityTakeOff - Reference: Column#33; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#34, Column#34
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#34
Pset_QuantityTakeOff - Reference: Column#34; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#35, Column#35
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#35
Pset_QuantityTakeOff - Reference: Column#35; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#36, Column#36
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#36
Pset_QuantityTakeOff - Reference: Column#36; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#37, Column#37
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#37
Pset_QuantityTakeOff - Reference: Column#37; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#38, Column#38
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#38
Pset_QuantityTakeOff - Reference: Column#38; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#39, Column#39
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#39
Pset_QuantityTakeOff - Reference: Column#39; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#40, Column#40
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#40
Pset_QuantityTakeOff - Reference: Column#40; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#41, Column#41
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#41
Pset_QuantityTakeOff - Reference: Column#41; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#42, Column#42
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#42
Pset_QuantityTakeOff - Reference: Column#42; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#43, Column#43
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#43
Pset_QuantityTakeOff - Reference: Column#43; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#44, Column#44
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#44
Pset_QuantityTakeOff - Reference: Column#44; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#45, Column#45
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#45
Pset_QuantityTakeOff - Reference: Column#45; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#46, Column#46
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#46
Pset_QuantityTakeOff - Reference: Column#46; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#47, Column#47
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#47
Pset_QuantityTakeOff - Reference: Column#47; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#48, Column#48
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#48
Pset_QuantityTakeOff - Reference: Column#48; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#49, Column#49
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#49
Pset_QuantityTakeOff - Reference: Column#49; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#50, Column#50
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#50
Pset_QuantityTakeOff - Reference: Column#50; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#61, Column#61
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#61
Pset_QuantityTakeOff - Reference: Column#61; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcColumn: Direct Shape:Column#9, Column#9
In: L1
Type - PredefinedType: COLUMN; Material: <Unnamed>
Type - Pset_ColumnCommon - Slope: 0 deg
Pset_ColumnCommon - IsExternal: no; Reference: Column#9
Pset_QuantityTakeOff - Reference: Column#9; sets with these values: 2
Group: Model Group:D_30_2L_OF_S_Sub:1246183

# IfcGroup: Model Group:D_30_2L_OF_S_Sub, Model Group:D_30_2L_OF_S_Sub:1246183
Group: Model Group:Group 1:1246292
