Properties of the parts of a building model (IFC2X3)

# File
Description: model build from MIDAS
Time: 2026-06-10T16:16:35

# IfcProject, D_45_3L_NF_P_Superstructure
LongName: D_45_3L_NF_P_Superstructure

# IfcBuildingStorey, floor#1
In: The building
Elevation: -2.63 m
