Properties of the parts of a building model (IFC2X3)

# File
Description: model build from MIDAS
Time: 2026-06-10T15:15:12

# IfcProject, D_25_2L_NF_P_Superstructure
LongName: D_25_2L_NF_P_Superstructure

# IfcBuildingStorey, floor#1
In: The building
Elevation: -2.03 m
